# Keil uVision project fortuna.uvprojx, settings and files
target fortuna (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: abx081 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99 --locale=english
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/BSP/board;../Drivers/BSP/components/digit_led;../Drivers/BSP/components/ntc;../Src/tasks/;../Src/at_cmd_set;../Src/at_cmd_set/port;../Src/json;../Src/service;../Src/eeprom;../libraries/app_log;../libraries/app_error;../libraries/CPU;../libraries/SEGGER_RTT_V612j/RTT;../libraries/SEGGER_RTT_V612j/Syscalls
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: freertos.c i2c.c main.c stm32f1xx_it.c tim.c dma.c stm32f1xx_hal_msp.c iwdg.c adc.c gpio.c usart.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c croutine.c timers.c tasks.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_adc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c
  group Application/at_cmd_set
    ../Src/at_cmd_set/: at_cmd_set.c
    ../Src/at_cmd_set/port/: at_cmd_port_serial.c at_cmd_port_timer.c
  group Application/json
    ../Src/json/: json.c
  group Application/service
    ../Src/service/: service.c
  group Application/eeprom
    ../Src/eeprom/: eeprom.c
  group Application/tasks
    ../Src/tasks/: compressor_task.c debug_task.c display_task.c door_status_task.c fan_ctrl_task.c glass_pwr_task.c light_ctrl_task.c lock_ctrl_task.c lock_status_task.c lock_switch_task.c report_task.c shopping_task.c sys_led_task.c temperature_cache_task.c temperature_task.c ups_status_task.c watch_dog_task.c
  group Drivers/BSP/board
    ../Drivers/BSP/board/: ABDK_ABX081_ZK.c
  group Drivers/BSP/commponents/digit_led
    ../Drivers/BSP/components/digit_led/: digit_led.c
  group Drivers/BSP/commponents/ntc
    ../Drivers/BSP/components/ntc/: ntc_3950.c
  group libraries/app_log
    ../libraries/app_log/: app_log.c app_log_port.c
  group libraries/app_error
    ../libraries/app_error/: app_error.c
  group libraries/segger_rtt
    ../libraries/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../libraries/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
  group libraries/cpu
    ../libraries/CPU/: cpu_utils.c
software components: CMSIS:CORE 4.1.0
