# IAR project fortuna.ewp, settings and files
configuration fortuna (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/tasks; ../Src/service; ../Src/at_cmd_set; ../Src/at_cmd_set/port; ../Src/json; ../libraries/app_log; ../libraries/app_error; ../libraries/SEGGER_RTT_V612j/RTT; ../libraries/SEGGER_RTT_V612j/Syscalls; ../libraries/CPU; ../Drivers/BSP/board; ../Drivers/BSP/common; ../Drivers/BSP/components/ntc; ../Drivers/BSP/components/digit_led
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: abx081.bin
  ILINK.IlinkOutputFile: abx081.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: adc.c dma.c freertos.c gpio.c iwdg.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Application/User/at_cmd_set
    ../Src/at_cmd_set/: at_cmd_set.c
  group Application/User/at_cmd_set/port
    ../Src/at_cmd_set/port/: at_cmd_port_serial.c at_cmd_port_timer.c
  group Application/User/json
    ../Src/json/: json.c
  group Application/User/service
    ../Src/service/: service.c
  group Application/User/tasks
    ../Src/tasks/: compressor_task.c debug_task.c display_task.c door_status_task.c fan_ctrl_task.c glass_pwr_task.c light_ctrl_task.c lock_ctrl_task.c lock_status_task.c lock_switch_task.c report_task.c shopping_task.c sys_led_task.c temperature_cache_task.c temperature_task.c ups_status_task.c watch_dog_task.c
  group Drivers/BSP/board
    ../Drivers/BSP/board/: ABDK_ABX081_ZK.c
  group Drivers/BSP/components/digit_led
    ../Drivers/BSP/components/digit_led/: digit_led.c
  group Drivers/BSP/components/ntc
    ../Drivers/BSP/components/ntc/: ntc_3950.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group libraries/app_error
    ../libraries/app_error/: app_error.c
  group libraries/app_log
    ../libraries/app_log/: app_log.c app_log_port.c
  group libraries/cpu
    ../libraries/CPU/: cpu_utils.c
  group libraries/segger_rtt/rtt
    ../libraries/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group libraries/segger_rtt/syscalls
    ../libraries/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
